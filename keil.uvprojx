# Keil uVision project keil.uvprojx, settings and files
target STM32F412 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F412CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keil +hex
  c flags: Optim=4 v6Lang=5 v6LangP=8 wLevel=2
  c include: .\lib;.\src;.\test;.\include;.\lib\UART;.\lib\RingBuffer;.\lib\SysClock;.\lib\Random
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group user
    ./src/: main.cpp
    ./lib/SysClock/: sys_clock.cpp
    ./lib/RingBuffer/: ring_buffer.h
    ./lib/UART/: uart.hpp
    ./lib/Random/: random.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
